** sch_path: sram512_input_clamp.sch
**.subckt sram512_input_clamp IN VDD VSS
*.iopin IN
*.iopin VDD
*.iopin VSS
Dxupper IN VDD DP m=1
Dxlower VSS IN DN m=1
**.ends
.end
